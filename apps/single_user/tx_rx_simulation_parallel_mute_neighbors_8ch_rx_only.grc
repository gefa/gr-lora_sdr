options:
  parameters:
    generate_options: no_gui
    id: tx_rx_simulation_parallel_mute_neighbors_8ch_rx_only
    output_language: python
    realtime_scheduling: '1'
    run_options: run
  states: {}

blocks:
- name: Samp_Rate
  id: variable
  parameters:
    value: samp_rate*16
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '2000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 0*904300000+905000000+tx_offset
  states: {}
- name: freq_1
  id: variable
  parameters:
    value: '905000000'
  states: {state: disabled}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: net_id
  id: variable
  parameters:
    value: '0x34'
  states: {}
- name: noise
  id: variable
  parameters:
    value: numpy.sqrt((10.0**(-esno/10.0))/2.0)
  states: {state: disabled}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: tx_offset
  id: variable
  parameters:
    value: '-1*300e3'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9043_2msps.iq
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9043_500ksps.iq
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9039_500ksps.iq
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9041_500ksps.iq
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9049_500ksps.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9047_500ksps.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9045_500ksps.iq
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9053_500ksps.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_2
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_9051_500ksps.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/gr-lora_sdr/lora_905_2msps.iq
    type: complex
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Hello world")
    period: frame_period
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: 0.0/2**sf
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 0.0j
  states: {state: disabled}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: 0.0/2**sf
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 0.0j
  states: {state: disabled}
- name: esno
  id: parameter
  parameters:
    label: esno
    short_id: e
    type: intx
    value: '-10'
  states: {state: disabled}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '4'
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccc
  states: {state: disabled}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: firdes.complex_band_pass(1, Samp_Rate, -Samp_Rate/(2*decimation*4), Samp_Rate/(2*decimation*4), transition_bw)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '4'
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-400000'
    decim: decimation
    samp_rate: Samp_Rate
    taps: firdes.complex_band_pass(1, Samp_Rate, -Samp_Rate/(2*decimation*4), Samp_Rate/(2*decimation*4), transition_bw)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-200000'
    decim: decimation
    samp_rate: Samp_Rate
    taps: firdes.complex_band_pass(1, Samp_Rate, -Samp_Rate/(2*decimation*4), Samp_Rate/(2*decimation*4), transition_bw)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '200000'
    decim: decimation
    samp_rate: Samp_Rate
    taps: firdes.complex_band_pass(1, Samp_Rate, -Samp_Rate/(2*decimation*4), Samp_Rate/(2*decimation*4), transition_bw)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '100000'
    decim: decimation
    samp_rate: Samp_Rate
    taps: firdes.complex_band_pass(1, Samp_Rate, -Samp_Rate/(2*decimation*4), Samp_Rate/(2*decimation*4), transition_bw)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '200000'
    decim: decimation
    samp_rate: Samp_Rate
    taps: firdes.complex_band_pass(1, Samp_Rate, -Samp_Rate/(2*decimation*4), Samp_Rate/(2*decimation*4), transition_bw)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-100000'
    decim: decimation
    samp_rate: Samp_Rate
    taps: firdes.complex_band_pass(1, Samp_Rate, -Samp_Rate/(2*decimation*4), Samp_Rate/(2*decimation*4), transition_bw)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-300000'
    decim: decimation
    samp_rate: Samp_Rate
    taps: firdes.complex_band_pass(1, Samp_Rate, -Samp_Rate/(2*decimation*4), Samp_Rate/(2*decimation*4), transition_bw)
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: '20000'
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccf
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: '20000'
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), transition_bw)'
    type: ccf
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: '20000'
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccf
  states: {state: disabled}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {state: disabled}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_crc_verif_0_0_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_crc_verif_0_0_0_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_crc_verif_0_0_1
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_crc_verif_0_0_1_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_crc_verif_0_0_2
  id: lora_sdr_crc_verif
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_crc_verif_0_1
  id: lora_sdr_crc_verif
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_deinterleaver_0_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_deinterleaver_0_0_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_deinterleaver_0_0_0_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0_0_1
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_deinterleaver_0_0_1_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0_0_2
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0_1
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_dewhitening_0_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0_1_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_dewhitening_0_0_2
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_dewhitening_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: sf
  states: {}
- name: lora_sdr_fft_demod_0_0
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: sf
  states: {}
- name: lora_sdr_fft_demod_0_0_0
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: sf
  states: {}
- name: lora_sdr_fft_demod_0_0_0_0
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: sf
  states: {state: disabled}
- name: lora_sdr_fft_demod_0_0_1
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: sf
  states: {}
- name: lora_sdr_fft_demod_0_0_1_0
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: sf
  states: {state: disabled}
- name: lora_sdr_fft_demod_0_0_2
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: sf
  states: {state: disabled}
- name: lora_sdr_fft_demod_0_1
  id: lora_sdr_fft_demod
  parameters:
    impl_head: impl_head
    sf: sf
  states: {state: disabled}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_word: net_id
  states: {}
- name: lora_sdr_frame_sync_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_word: net_id
  states: {}
- name: lora_sdr_frame_sync_0_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw*4
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_word: net_id
  states: {}
- name: lora_sdr_frame_sync_0_0_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_word: net_id
  states: {state: disabled}
- name: lora_sdr_frame_sync_0_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_word: net_id
  states: {}
- name: lora_sdr_frame_sync_0_0_1_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_word: net_id
  states: {state: disabled}
- name: lora_sdr_frame_sync_0_0_2
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_word: net_id
  states: {state: disabled}
- name: lora_sdr_frame_sync_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_word: net_id
  states: {state: disabled}
- name: lora_sdr_gray_decode_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_gray_enc_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_gray_enc_0_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_gray_enc_0_0_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_gray_enc_0_0_0_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_gray_enc_0_0_1
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_gray_enc_0_0_1_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_gray_enc_0_0_2
  id: lora_sdr_gray_enc
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_gray_enc_0_1
  id: lora_sdr_gray_enc
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0_0_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0_0_0_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0_0_1
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0_0_1_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0_0_2
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0_1
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {state: disabled}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {state: disabled}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_header_decoder_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_header_decoder_0_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_header_decoder_0_0_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {state: disabled}
- name: lora_sdr_header_decoder_0_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_header_decoder_0_0_1_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {state: disabled}
- name: lora_sdr_header_decoder_0_0_2
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {state: disabled}
- name: lora_sdr_header_decoder_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {state: disabled}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf
  states: {state: disabled}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    minoutbuf: '10000000'
    samp_rate: samp_rate*4
    sf: sf
    sync_words: net_id
  states: {state: disabled}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters: {}
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: public network 52=0x34; private nwk 18=0x12
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    note: BW times 4 ????
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtlsdr"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl_tcp"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq+tx_offset
    dev_args: '"serial=3134B8C"'
    gain0: '40'
    len_tag_name: frame_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '"serial=31E9D7D"'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: Samp_Rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq_1
    dc_offs_enb0: '""'
    dev_args: '"serial=31EEB59"'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: Samp_Rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_message_strobe_0_0, strobe, lora_sdr_whitening_0, msg]
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']
- [channels_channel_model_0, '0', interp_fir_filter_xxx_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_file_sink_0_0, '0']
- [fir_filter_xxx_0_0, '0', lora_sdr_frame_sync_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', lora_sdr_frame_sync_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_file_sink_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', lora_sdr_frame_sync_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', blocks_file_sink_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', lora_sdr_frame_sync_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', blocks_file_sink_0_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', lora_sdr_frame_sync_0_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_file_sink_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', lora_sdr_frame_sync_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_file_sink_0_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', lora_sdr_frame_sync_0_1, '0']
- [interp_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_deinterleaver_0_0, '0', lora_sdr_hamming_dec_0_0, '0']
- [lora_sdr_deinterleaver_0_0_0, '0', lora_sdr_hamming_dec_0_0_0, '0']
- [lora_sdr_deinterleaver_0_0_0_0, '0', lora_sdr_hamming_dec_0_0_0_0, '0']
- [lora_sdr_deinterleaver_0_0_1, '0', lora_sdr_hamming_dec_0_0_1, '0']
- [lora_sdr_deinterleaver_0_0_1_0, '0', lora_sdr_hamming_dec_0_0_1_0, '0']
- [lora_sdr_deinterleaver_0_0_2, '0', lora_sdr_hamming_dec_0_0_2, '0']
- [lora_sdr_deinterleaver_0_1, '0', lora_sdr_hamming_dec_0_1, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_dewhitening_0_0_0, '0', lora_sdr_crc_verif_0_0_0, '0']
- [lora_sdr_dewhitening_0_0_0_0, '0', lora_sdr_crc_verif_0_0_0_0, '0']
- [lora_sdr_dewhitening_0_0_1, '0', lora_sdr_crc_verif_0_0_1, '0']
- [lora_sdr_dewhitening_0_0_1_0, '0', lora_sdr_crc_verif_0_0_1_0, '0']
- [lora_sdr_dewhitening_0_0_2, '0', lora_sdr_crc_verif_0_0_2, '0']
- [lora_sdr_dewhitening_0_1, '0', lora_sdr_crc_verif_0_1, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_enc_0, '0']
- [lora_sdr_fft_demod_0_0, '0', lora_sdr_gray_enc_0_0, '0']
- [lora_sdr_fft_demod_0_0_0, '0', lora_sdr_gray_enc_0_0_0, '0']
- [lora_sdr_fft_demod_0_0_0_0, '0', lora_sdr_gray_enc_0_0_0_0, '0']
- [lora_sdr_fft_demod_0_0_1, '0', lora_sdr_gray_enc_0_0_1, '0']
- [lora_sdr_fft_demod_0_0_1_0, '0', lora_sdr_gray_enc_0_0_1_0, '0']
- [lora_sdr_fft_demod_0_0_2, '0', lora_sdr_gray_enc_0_0_2, '0']
- [lora_sdr_fft_demod_0_1, '0', lora_sdr_gray_enc_0_1, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0_0, '0', lora_sdr_fft_demod_0_0, '0']
- [lora_sdr_frame_sync_0_0_0, '0', lora_sdr_fft_demod_0_0_0, '0']
- [lora_sdr_frame_sync_0_0_0_0, '0', lora_sdr_fft_demod_0_0_0_0, '0']
- [lora_sdr_frame_sync_0_0_1, '0', lora_sdr_fft_demod_0_0_1, '0']
- [lora_sdr_frame_sync_0_0_1_0, '0', lora_sdr_fft_demod_0_0_1_0, '0']
- [lora_sdr_frame_sync_0_0_2, '0', lora_sdr_fft_demod_0_0_2, '0']
- [lora_sdr_frame_sync_0_1, '0', lora_sdr_fft_demod_0_1, '0']
- [lora_sdr_gray_decode_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_enc_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_gray_enc_0_0, '0', lora_sdr_deinterleaver_0_0, '0']
- [lora_sdr_gray_enc_0_0_0, '0', lora_sdr_deinterleaver_0_0_0, '0']
- [lora_sdr_gray_enc_0_0_0_0, '0', lora_sdr_deinterleaver_0_0_0_0, '0']
- [lora_sdr_gray_enc_0_0_1, '0', lora_sdr_deinterleaver_0_0_1, '0']
- [lora_sdr_gray_enc_0_0_1_0, '0', lora_sdr_deinterleaver_0_0_1_0, '0']
- [lora_sdr_gray_enc_0_0_2, '0', lora_sdr_deinterleaver_0_0_2, '0']
- [lora_sdr_gray_enc_0_1, '0', lora_sdr_deinterleaver_0_1, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_dec_0_0, '0', lora_sdr_header_decoder_0_0, '0']
- [lora_sdr_hamming_dec_0_0_0, '0', lora_sdr_header_decoder_0_0_0, '0']
- [lora_sdr_hamming_dec_0_0_0_0, '0', lora_sdr_header_decoder_0_0_0_0, '0']
- [lora_sdr_hamming_dec_0_0_1, '0', lora_sdr_header_decoder_0_0_1, '0']
- [lora_sdr_hamming_dec_0_0_1_0, '0', lora_sdr_header_decoder_0_0_1_0, '0']
- [lora_sdr_hamming_dec_0_0_2, '0', lora_sdr_header_decoder_0_0_2, '0']
- [lora_sdr_hamming_dec_0_1, '0', lora_sdr_header_decoder_0_1, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', fec_ber_bf_0, '1']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_header_decoder_0_0, '0', lora_sdr_dewhitening_0_0, '0']
- [lora_sdr_header_decoder_0_0, frame_info, lora_sdr_frame_sync_0_0, frame_info]
- [lora_sdr_header_decoder_0_0_0, '0', lora_sdr_dewhitening_0_0_0, '0']
- [lora_sdr_header_decoder_0_0_0, frame_info, lora_sdr_frame_sync_0_0_0, frame_info]
- [lora_sdr_header_decoder_0_0_0_0, '0', lora_sdr_dewhitening_0_0_0_0, '0']
- [lora_sdr_header_decoder_0_0_0_0, frame_info, lora_sdr_frame_sync_0_0_0_0, frame_info]
- [lora_sdr_header_decoder_0_0_1, '0', lora_sdr_dewhitening_0_0_1, '0']
- [lora_sdr_header_decoder_0_0_1, frame_info, lora_sdr_frame_sync_0_0_1, frame_info]
- [lora_sdr_header_decoder_0_0_1_0, '0', lora_sdr_dewhitening_0_0_1_0, '0']
- [lora_sdr_header_decoder_0_0_1_0, frame_info, lora_sdr_frame_sync_0_0_1_0, frame_info]
- [lora_sdr_header_decoder_0_0_2, '0', lora_sdr_dewhitening_0_0_2, '0']
- [lora_sdr_header_decoder_0_0_2, frame_info, lora_sdr_frame_sync_0_0_2, frame_info]
- [lora_sdr_header_decoder_0_1, '0', lora_sdr_dewhitening_0_1, '0']
- [lora_sdr_header_decoder_0_1, frame_info, lora_sdr_frame_sync_0_1, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_decode_0, '0']
- [lora_sdr_modulate_0, '0', blocks_throttle_0, '0']
- [lora_sdr_modulate_0, '0', uhd_usrp_sink_0, '0']
- [lora_sdr_whitening_0, '0', fec_ber_bf_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [osmosdr_source_0, '0', interp_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', interp_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', interp_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_file_sink_0_1, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']

metadata:
  file_format: 1
