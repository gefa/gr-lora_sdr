options:
  parameters:
    generate_options: no_gui
    id: lora_sim_ota
    output_language: python
  states: {}

blocks:
- name: TX_gain
  id: variable
  parameters:
    value: 3*7
  states: {}
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: mean
  id: variable
  parameters:
    value: '200'
  states: {}
- name: multi_control
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '200'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"/home/gnuradio/lora_rx.iq"'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Hello world")
    period: '1000'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: disabled}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    exit: 'True'
  states: {}
- name: lora_sdr_data_source_sim_0
  id: lora_sdr_data_source_sim
  parameters:
    mean: mean
    multi_control: multi_control
    n_frames: n_frame
    pay_len: pay_len
    string_input: ''
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_gray_decode_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_enc_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    create_zeros: 'False'
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters: {}
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: 915e6
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: TX_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bw
    center_freq0: 915e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_sdr_add_crc_0, msg]
- [blocks_message_strobe_0, strobe, lora_sdr_header_0, msg]
- [blocks_message_strobe_0, strobe, lora_sdr_interleaver_0, msg]
- [blocks_message_strobe_0, strobe, lora_sdr_modulate_0, msg]
- [blocks_message_strobe_0, strobe, lora_sdr_whitening_0, msg]
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, msg, blocks_message_debug_0, print]
- [lora_sdr_data_source_sim_0, '0', lora_sdr_whitening_0, '0']
- [lora_sdr_data_source_sim_0, msg, lora_sdr_add_crc_0, msg]
- [lora_sdr_data_source_sim_0, msg, lora_sdr_header_0, msg]
- [lora_sdr_data_source_sim_0, msg, lora_sdr_interleaver_0, msg]
- [lora_sdr_data_source_sim_0, msg, lora_sdr_modulate_0, msg]
- [lora_sdr_data_source_sim_0, msg, lora_sdr_whitening_0, msg]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_enc_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_deinterleaver_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_dewhitening_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_fft_demod_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_hamming_dec_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_header_decoder_0, new_frame]
- [lora_sdr_gray_decode_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_enc_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, CR, lora_sdr_deinterleaver_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_fft_demod_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_frame_sync_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_hamming_dec_0, CR]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_crc_verif_0, CRC]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_dewhitening_0, CRC]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_frame_sync_0, crc]
- [lora_sdr_header_decoder_0, err, lora_sdr_frame_sync_0, err]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_crc_verif_0, pay_len]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_dewhitening_0, pay_len]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_frame_sync_0, pay_len]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_decode_0, '0']
- [lora_sdr_modulate_0, '0', uhd_usrp_sink_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', lora_sdr_frame_sync_0, '0']

metadata:
  file_format: 1
